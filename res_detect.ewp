# IAR project res_detect.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430ff.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 150
  General.GHeapSize2: 150
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: source
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 1
  A430.AUserIncludes: D:\RES_dectect\v3\source
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: C:\Users\Administrator\Desktop\res_detect_V3\source
  ICC430.CCOptLevel: 3
  ICC430.IccLang: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5133.xcl
  group (top)
    source/: data_proc.c data_proc.h GPIO.cpp GPIO.h key.cpp key.h oled.c oled.h oledfont.h uart.cpp uart.h warner.cpp warner.h
    ./: main.c
